# Keil uVision project STM32G070RB.uvprojx, settings and files
target STM32G070RB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00009000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32G070RB +hex
  AfterMake: D:\C251\ARM\ARMCC\bin\fromelf.exe
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32G070xx,USE_HAL_DRIVER,STM32G070xx
  c include: ../Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1d7ff
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: STM32G070RB\STM32G070RB.sct
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User
    ../Src/: gpio.c stm32g0xx_it.c i2c.c stm32g0xx_hal_msp.c rtc.c iwdg.c spi.c adc.c tim.c usart.c Font.c global variable.c Hardware.c AppUnlock.c OLEDdriver.c BeepMgr.c main.c FingerPrint.c EEPROM.c I2cBus.c LEDsMgr.c Flash.c GUI.c MFC.c RealTimeClock.c ISR.c CSK14.c TSM12S.c HostUART.c LCD_HFG12864.c FaceRecoginitionMgr.c PIR.c Radar.c YouzhiyunjiaWifi.c FM5114_Touch.c FM17622_LPCD_API.c
    ../Inc/: IO.h StdTypes.h Project.h main.h RealTimeClock.h ISR.h Hardware.h i2c.h EEPROM.h TSM12S.h I2cBus.h BeepMgr.h PIR.h Radar.h YouzhiyunjiaWifi.h FM5114_Touch.h FM17622_LPCD_API.h
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_gpio.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_spi.c
    ../Drivers/STM32G0xx_HAL_Driver/Inc/: stm32g0xx_hal_i2c.h stm32g0xx_hal_i2c_ex.h stm32g0xx_hal_gpio.h stm32g0xx_hal_gpio_ex.h
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
software components: CMSIS:CORE 5.4.0
